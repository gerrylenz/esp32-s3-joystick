## sdkconfig.defaults
```kconfig
# ESP_LOGD nur sichtbar wenn Log-Level auf Debug gesetzt (monitor: Ctrl+L → D)
CONFIG_LOG_DEFAULT_LEVEL_INFO=y
```
